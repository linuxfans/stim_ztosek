# Keil uVision project zt_osek.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2132 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: zt_osek +hex
  group Source Group 1
    ./: Startup.s ztosek_cpu.s dev_s.s zt_osek.c ztos_cpu.c dev_uart.c ztos_core.c dev_timer.c ztos_device.c
